# Keil uVision project Humidity.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Humidity
  c flags: Optim=1
  c define: STM32L15XXB_128K USE_STDPERIPH_DRIVER
  c include: ..\STM32L1xx_StdPeriph_Driver\inc;..\Board;.\;..\..\..\..\INC\ST\STM32L1xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32l1xx_md.s ext_glcd.c main.c system_stm32l1xx.c onewire.c 18b20.c dht11.c ds2417.c uart.c pin.c rtc.c tim.c delay.c adc.c
  group New Group
    ../STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c misc.c stm32l1xx_exti.c stm32l1xx_dma.c stm32l1xx_adc.c stm32l1xx_flash.c stm32l1xx_pwr.c stm32l1xx_dac.c
